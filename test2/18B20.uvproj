# Keil uVision project 18B20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S8252 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000) MODA2
  output: 18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 18B20TEST.c

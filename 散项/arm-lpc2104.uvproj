# Keil uVision project arm-lpc2104.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC2104 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: arm-lpc2104
